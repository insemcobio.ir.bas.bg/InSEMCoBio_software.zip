classdef ProcessControlPanel < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        GluconicAcidProcessControlUIFigure  matlab.ui.Figure
        Panel                          matlab.ui.container.Panel
        ProcessmodelLabel              matlab.ui.control.Label
        dXedtXeGQaDXeLabel             matlab.ui.control.Label
        dGdtXeGQbGOQcDGGinLabel        matlab.ui.control.Label
        ControllawLabel                matlab.ui.control.Label
        StartButton                    matlab.ui.control.Button
        ButtonGroup                    matlab.ui.container.ButtonGroup
        GliconicacidconcentrationButton  matlab.ui.control.RadioButton
        GlucoseconcentrationButton     matlab.ui.control.RadioButton
        dGAedtGOQfDGAeLabel            matlab.ui.control.Label
        DlambdaGGXeGQbGOQcGGinLabel    matlab.ui.control.Label
        dOdtGOQdDOKlaOOLabel           matlab.ui.control.Label
        DlambdaGAGAeXeGQbGOQfGAeLabel  matlab.ui.control.Label
    end


    methods (Access = private)
    
        function figure = centerFigure(app, figure)
            % width and height of the figure
            width = figure.Position(3);
            height = figure.Position(4);
            
            % screen size
            sz = get( 0, 'ScreenSize');
            
            % center position
            x = mean( sz( [1, 3]));
            y = mean( sz( [2, 4]));
            
            figure.Position = [x - width/2, y - height/2, width, height];
        end
        
    end


    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            app.GluconicAcidProcessControlUIFigure = app.centerFigure(app.GluconicAcidProcessControlUIFigure);
        end

        % Button pushed function: StartButton
        function StartButtonPushed(app, event)
            
            if app.GliconicacidconcentrationButton.Value == 1
                CluconicAcidConcentationControl.run();
            else
                GlucoseConcentationControl.run();
            end
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.GluconicAcidProcessControlUIFigure = uifigure;
            app.GluconicAcidProcessControlUIFigure.Name = 'Gluconic Acid Process Control';
            app.Panel = uipanel(app.GluconicAcidProcessControlUIFigure);
            app.ProcessmodelLabel = uilabel(app.Panel);
            app.ProcessmodelLabel.Text = 'Process model';
            app.dXedtXeGQaDXeLabel = uilabel(app.Panel);
            app.dXedtXeGQaDXeLabel.Text = 'dXe/dt = XeGQa - DXe';
            app.dGdtXeGQbGOQcDGGinLabel = uilabel(app.Panel);
            app.dGdtXeGQbGOQcDGGinLabel.Text = 'dG/dt = - XeGQb - GOQc - D(G - Gin)';
            app.ControllawLabel = uilabel(app.Panel);
            app.ControllawLabel.Text = 'Control law';
            app.StartButton = uibutton(app.Panel, 'push');
            app.StartButton.ButtonPushedFcn = createCallbackFcn(app, @StartButtonPushed, true);
            app.StartButton.Text = 'Start';
            app.ButtonGroup = uibuttongroup(app.Panel);
            app.GliconicacidconcentrationButton = uiradiobutton(app.ButtonGroup);
            app.GliconicacidconcentrationButton.Text = 'Gliconic acid concentration';
            app.GliconicacidconcentrationButton.Value = true;
            app.GlucoseconcentrationButton = uiradiobutton(app.ButtonGroup);
            app.GlucoseconcentrationButton.Text = 'Glucose concentration';
            app.dGAedtGOQfDGAeLabel = uilabel(app.Panel);
            app.dGAedtGOQfDGAeLabel.Text = 'dGAe/dt = GOQf - DGAe';
            app.DlambdaGGXeGQbGOQcGGinLabel = uilabel(app.Panel);
            app.DlambdaGGXeGQbGOQcGGinLabel.Text = 'D = (-lambda(G* - G) - XeGQb - GOQc ) / (G - Gin)';
            app.dOdtGOQdDOKlaOOLabel = uilabel(app.Panel);
            app.dOdtGOQdDOKlaOOLabel.Text = 'dO/dt = - GOQd - DO + Kla(O* - O)';
            app.DlambdaGAGAeXeGQbGOQfGAeLabel = uilabel(app.Panel);
            app.DlambdaGAGAeXeGQbGOQfGAeLabel.Text = 'D = (-lambda(GA* - GAe) - XeGQb + GOQf ) / GAe';
        end
    end

    methods (Access = public)

        % Construct app
        function app = ProcessControlPanel

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.GluconicAcidProcessControlUIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.GluconicAcidProcessControlUIFigure)
        end
    end
end