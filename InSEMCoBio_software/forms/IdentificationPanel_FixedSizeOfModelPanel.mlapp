classdef IdentificationPanel_FixedSizeOfModelPanel < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        IdentificationPanelUIFigure     matlab.ui.Figure
        IdentificationMainPanel         matlab.ui.container.Panel
        NavigaationPanel                matlab.ui.container.Panel
        StepInfoPanel                   matlab.ui.container.Panel
        SelectFermentionProcessCheckBox  matlab.ui.control.CheckBox
        SelectModelandKineticsCheckBox  matlab.ui.control.CheckBox
        ModelParameterIdentificationCheckBox  matlab.ui.control.CheckBox
        LoadExperimentalDataCheckBox    matlab.ui.control.CheckBox
        GluconicAcidProcessControlButton  matlab.ui.control.Button
        SettingsPanel                   matlab.ui.container.Panel
        SettingsOfFermentationProcessPanel  matlab.ui.container.Panel
        ModelKineticsPanel              matlab.ui.container.Panel
        KineticsPanel                   matlab.ui.container.ButtonGroup
        MassBalanceEquationsPanel       matlab.ui.container.Panel
        SetModelButtonPanel             matlab.ui.container.Panel
        SetModelButton                  matlab.ui.control.Button
        LoadDataButton                  matlab.ui.control.StateButton
        ProcessTypePanel                matlab.ui.container.Panel
        ProcessDropDown                 matlab.ui.control.DropDown
        InformationPanel                matlab.ui.container.Panel
        LogsPanel                       matlab.ui.container.Panel
        LogsUITable                     matlab.ui.control.Table
        SimulationResultsUITable        matlab.ui.control.Table
        CompareResultsButton            matlab.ui.control.Button
        OptimizationAlgorithmPanel      matlab.ui.container.Panel
        AlgorithmDropDown               matlab.ui.control.DropDown
        OptimizationAlgorithmParametersPanel  matlab.ui.container.Panel
        GAParametersPanel               matlab.ui.container.Panel
        MUTRLabel                       matlab.ui.control.Label
        MutrEditField                   matlab.ui.control.NumericEditField
        MutrRangeLabel                  matlab.ui.control.Label
        XovrRangeLabel                  matlab.ui.control.Label
        XOVRLabel                       matlab.ui.control.Label
        XovrEditField                   matlab.ui.control.NumericEditField
        NindRangeLabel                  matlab.ui.control.Label
        NINDLabel                       matlab.ui.control.Label
        NindEditField                   matlab.ui.control.NumericEditField
        MaxGenRangeLabel                matlab.ui.control.Label
        MAXGENLabel                     matlab.ui.control.Label
        MaxGenEditField                 matlab.ui.control.NumericEditField
        GGapRangeLabel                  matlab.ui.control.Label
        GGAPLabel                       matlab.ui.control.Label
        GGapEditField                   matlab.ui.control.NumericEditField
        NRunRangeLabel                  matlab.ui.control.Label
        NRUNLabel                       matlab.ui.control.Label
        NRunEditField                   matlab.ui.control.NumericEditField
        ParametersPanel                 matlab.ui.container.Panel
        ProblemParametersPanel          matlab.ui.container.Panel
        RunSimulationButtonsPanel       matlab.ui.container.Panel
        RunButton                       matlab.ui.control.Button
    end

    properties
        system    System
        
        descriptionOfSelectedProcess    FermentationProcessDescription
        selectedProcess    FermentationProcess
        
        descriptionOfAlgorithm    AlgorithmDescription
        selectedAlgorithm    OptimizationAlgorithm
        
        % height of a checkbox or a radiobox control
        controlHeight = 25;
        
        textFieldWidth = 50;
        labelWidth = 70;
        
        % distance between the panels
        distanceBetweenPanels = 10;
        
        % distance between controls
        distanceBetweenControls = 5;
        
        % header and footer heights
        headerHeight = 25;
        footerHeight = 10;
        
        % list of checkboxes
        modelEquationsCheckBoxesGroup
    end
    
    methods (Access = private)
        
        %% add row into the log table
        function logInfo(app, stepCode, record)
            
            currentData = app.LogsUITable.Data;
            
            newRecord = {stepCode, char(record)};
            currentData = [currentData; newRecord];
                      
            app.LogsUITable.Data = currentData;
        end
        
        %% add record into the ui table with the results
        function addResultRecord(app, bestSolution, meanError, filename)
            
            persistent count
            if isempty(count)
                count = 0;
            end
            count = count + 1;
            
            % generate description for the optimization algorithm, fermentation process, model and kinetics
            problemDescription = app.selectedProcess.toString();
            algorithmShortName = [char(app.selectedAlgorithm.description.shortName) num2str(count)];
            
            % generate the solution string
            solutionString = app.selectedProcess.model.resultToString(bestSolution, meanError);
            
            currentData = app.SimulationResultsUITable.Data;
            
            newRecord = {false, problemDescription, algorithmShortName, solutionString, filename};
            currentData = [currentData; newRecord];
                      
            app.SimulationResultsUITable.Data = currentData;
        end
        
        %% draws the settings panel
        function app = drawSettingsPanel(app, descriptionOfFermentationProcess)
                                   
            numberOfEquations = length(descriptionOfFermentationProcess.generalModelDescription.elements);
            numberOfApplicableKinetics = length(descriptionOfFermentationProcess.listOfKinetics);
            
            maxNumberOfControls = max(numberOfEquations, numberOfApplicableKinetics);
            
            % change the height of the parent panels
            massBalanceEquationsPanelHeight = maxNumberOfControls*(app.controlHeight + app.distanceBetweenControls) + app.footerHeight + app.headerHeight;
          
            modelKineticsPanelHeight = ... % app.distanceBetweenPanels +
                app.SetModelButtonPanel.Position(4) + app.distanceBetweenPanels + ...
                massBalanceEquationsPanelHeight + app.headerHeight;
            
            settingsOfFermentationPanelHeight = modelKineticsPanelHeight + app.distanceBetweenPanels + app.ProcessTypePanel.Position(4);
            
            app.SettingsOfFermentationProcessPanel.Position(1) = 0;
            app.SettingsOfFermentationProcessPanel.Position(2) = app.SettingsPanel.Position(4) - settingsOfFermentationPanelHeight;
            app.SettingsOfFermentationProcessPanel.Position(3) = app.SettingsPanel.Position(3);
            app.SettingsOfFermentationProcessPanel.Position(4) = settingsOfFermentationPanelHeight;
            
            app.ModelKineticsPanel.Position(1) = 0;
            app.ModelKineticsPanel.Position(2) = 0;
            app.ModelKineticsPanel.Position(3) = app.SettingsOfFermentationProcessPanel.Position(3);
            app.ModelKineticsPanel.Position(4) = modelKineticsPanelHeight;
            
            app.ProcessTypePanel.Position(1) = 0;
            app.ProcessTypePanel.Position(2) = app.ModelKineticsPanel.Position(2) + app.distanceBetweenPanels + app.ModelKineticsPanel.Position(4);
            app.ProcessTypePanel.Position(3) = app.SettingsOfFermentationProcessPanel.Position(3);
            app.ProcessTypePanel.Position(4) = 80;
            
            app.SetModelButtonPanel.Position(1) = 0; % app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(2) = 0; % app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(3) = app.ModelKineticsPanel.Position(3); %- 2*app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(4) = 60;
            
            posY = app.SetModelButtonPanel.Position(2) + app.distanceBetweenPanels + app.SetModelButtonPanel.Position(4);
            
            app.MassBalanceEquationsPanel.Position(1) = app.distanceBetweenPanels;
            app.MassBalanceEquationsPanel.Position(2) = posY;
            app.MassBalanceEquationsPanel.Position(3) = 400;
            app.MassBalanceEquationsPanel.Position(4) = massBalanceEquationsPanelHeight;
            
            app.KineticsPanel.Position(1) = app.MassBalanceEquationsPanel.Position(1) + app.MassBalanceEquationsPanel.Position(3) + app.distanceBetweenPanels;
            app.KineticsPanel.Position(2) = posY;
            app.KineticsPanel.Position(3) = app.ModelKineticsPanel.Position(3) - app.MassBalanceEquationsPanel.Position(3) - 3*app.distanceBetweenPanels;
            app.KineticsPanel.Position(4) = massBalanceEquationsPanelHeight;
  
        end
        
        function clearChildrenPanels(app, panel)
            
            children = get(panel, 'Children');
            delete(children);
            
        end
        
        function clearStepInfoPanel(app)
            
            % app.SelectFermetationProcessCheckBox.Value = 0;
            app.SelectModelandKineticsCheckBox.Value = 0;
            app.ModelParameterIdentificationCheckBox.Value = 0;
            app.LoadExperimentalDataCheckBox.Value = 0;
            
        end
        
        %% load the list of equations for the selected process
        function loadMassBalanceEquationsPanel(app, descriptionOfFermentationProcess)
            
            if isempty(descriptionOfFermentationProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
                       
            numberOfEquations = length(descriptionOfFermentationProcess.generalModelDescription.elements);
                        
            checkBoxMaxWidth = app.MassBalanceEquationsPanel.Position(3) - 20;  
            emptySpace = ...
                app.MassBalanceEquationsPanel.Position(4) - app.headerHeight - app.footerHeight - ...
                numberOfEquations*(app.controlHeight + app.distanceBetweenControls);
            
                       
            for index = 1: numberOfEquations
                
                currentEquation = descriptionOfFermentationProcess.generalModelDescription.elements(index);
                positionY = emptySpace + app.footerHeight + (numberOfEquations - index)*(app.controlHeight + app.distanceBetweenControls);
                
                enabled = 'on';
                text = cellstr(currentEquation.equationText);
                value = 0;
                
                if currentEquation.isCompulsory
                    %enabled = 'off';
                    value = 1;
                end
                
                eqCheckBox = uicheckbox(app.MassBalanceEquationsPanel,...
                        'Visible', 'on', ...
                        'Enable', enabled, ...
                        'FontColor', 'k', ...
                        'Text', text, ...
                        'Position', [20 positionY checkBoxMaxWidth app.controlHeight], ...
                        'Value', value);
                    
                eqCheckBox.ValueChangedFcn = @(src, event) checkBoxChanged(app, src, event);
        
            end
            
             % array of the created checkboxes
            app.modelEquationsCheckBoxesGroup = get(app.MassBalanceEquationsPanel, 'Children');
        end
        
        %% change the list of kinetics when the extended model is selected
        function checkBoxChanged(app, source, event)
            
            % WARNING: the assumption is that the only active checkbox is the checkbox for the extended Ecoli model
            % TODO: check the source
            if string(source.Text) == 'dO2/dt = 1/Yox*mu*X + Kla*(O2* - O2) - F/V*O2'  
                visible = 'on';
                
                if event.Value
                  visible = 'off';
                end
                
                children = get(app.KineticsPanel, 'Children');
                
                children(1).Visible = visible;
                children(2).Visible = visible;
                children(3).Value = 1;
                
                % hide the algorithms
                app.OptimizationAlgorithmPanel.Visible = 'off';
                app.AlgorithmDropDown.Value = app.AlgorithmDropDown.ItemsData(1);
                
                app.ProblemParametersPanel.Visible = 'off';
                app.OptimizationAlgorithmParametersPanel.Visible = 'off';
            end
            
        end
        
        %% load radio buttons controls for the applicable kinetics
        function loadKineticsPanel(app, descriptionOfFermentationProcess)
            
            if isempty(descriptionOfFermentationProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
            
            numberOfApplicableKinetics = length(descriptionOfFermentationProcess.listOfKinetics);
            
            radioButtonMaxWidth = app.KineticsPanel.Position(3) - 40;
            value = 1;
                       
            for index = 1 : numberOfApplicableKinetics
                          
                text = cellstr(descriptionOfFermentationProcess.listOfKinetics(index));
                positionY = app.KineticsPanel.Position(4) - index*(app.controlHeight + app.distanceBetweenControls) - app.headerHeight;
                
                radioButton = uiradiobutton(app.KineticsPanel,...
                        'Visible', 'on', ...
                        'Enable', 'on', ...
                        'Text', text, ...
                        'Position', [20 positionY radioButtonMaxWidth app.controlHeight], ...
                        'Value', value);
                    
                value = 0;
            end
            
        end
        
        function setPanelsWhenFermetationProcessIsChosen(app, descriptionOfFermentationProcess, previousFermentationProcess)
                     
            % check if the current value is different from the previously selected one
            % only then change the panels
            if ~isempty(previousFermentationProcess) && previousFermentationProcess == descriptionOfFermentationProcess
                return;
            end
            
            if descriptionOfFermentationProcess.isEmpty()
                app.ModelKineticsPanel.Visible = 'Off';
                return;
            end
            
            app.SelectFermentionProcessCheckBox.Value = 1;
            app.logInfo('FP', descriptionOfFermentationProcess.description);
            
            % clear current content of the SettingsOfFermentationProcessPanel
            app.clearChildrenPanels(app.MassBalanceEquationsPanel);
            
            % clear current content of the KineticsPanel
            app.clearChildrenPanels(app.KineticsPanel);
            
            % rearrange the main panels
            %app = app.drawSettingsPanel(descriptionOfFermentationProcess);
            
            % Show the panel with the list of equations
            app.ModelKineticsPanel.Visible = 'On';
                
            % add the description of the equations to the panel
            app.loadMassBalanceEquationsPanel(descriptionOfFermentationProcess);
            
            % add the applicable kinetics for the selected proccess
            app.loadKineticsPanel(descriptionOfFermentationProcess);
            
            app.OptimizationAlgorithmParametersPanel.Visible = 'off';
            app.ProblemParametersPanel.Visible = 'off';
            app.OptimizationAlgorithmPanel.Visible = 'off';
            
        end
        
        function app = drawAlgorithmParametersPanel(app)
            
            if ~isempty(app.descriptionOfAlgorithm)
                listOfAlgrithmParameters = app.descriptionOfAlgorithm.parametersList;
                app.drawParametersPanel(listOfAlgrithmParameters, app.ParametersPanel);
            end
        end
                
        function app = drawProblemParametersPanel(app)
            if ~isempty(app.selectedProcess)
                listOfProblemParameters = app.selectedProcess.model.problemParametersList;

                app.drawParametersPanel(listOfProblemParameters, app.ProblemParametersPanel);
            end
        end
        
        function app = drawParametersPanel(app, listOfParameters, parentPanel)
            app.clearChildrenPanels(parentPanel);
            
            if ~isempty(listOfParameters)
                
                numberOfFields = length(listOfParameters);
                                
                panelHeight = app.ProblemParametersPanel.InnerPosition(4);
                
                emptySpace = panelHeight - app.footerHeight - app.headerHeight + ...
                    app. distanceBetweenControls - numberOfFields*(app.distanceBetweenControls + app.controlHeight);
                bottomLeftY =  app.footerHeight + emptySpace;
                
%                 if numberOfFields > 8
%                     app.ProblemParametersPanel.Scrollable = 'on';
%                 end
                
                for i = 1: numberOfFields
                    parameter = listOfParameters(numberOfFields - i + 1);
                    
                    bottomLeftX = 35;
                    label = uilabel(parentPanel);
                    label.HorizontalAlignment = 'right';
                    label.VerticalAlignment = 'center';
                    label.Position = [bottomLeftX bottomLeftY app.labelWidth app.controlHeight];
                    label.Text = char(parameter.name);
                    
                    bottomLeftX = bottomLeftX + app.labelWidth + app.distanceBetweenControls;
                    field = uieditfield(parentPanel, 'numeric');
                    field.Limits = [parameter.lowerBound parameter.upperBound];
                    field.Position = [bottomLeftX bottomLeftY app.textFieldWidth app.controlHeight];
                    field.Value = parameter.defaultValue;

                    bottomLeftX = bottomLeftX + app.textFieldWidth + app.distanceBetweenControls;
                    rangeLabel = uilabel(parentPanel);
                    rangeLabel.VerticalAlignment = 'center';
                    rangeLabel.Position = [bottomLeftX bottomLeftY app.labelWidth app.controlHeight];
                    rangeLabel.Text = ['(' num2str(parameter.lowerBound) ', ' num2str(parameter.upperBound) ')'];
            
                    bottomLeftY = bottomLeftY + app.distanceBetweenControls + app.controlHeight;
                end
            end
        end

        function selectedRows = getSelectedResultsForComparison(app)
            storedResults = app.SimulationResultsUITable.Data;
            
            % find indices of the selected rows
            idx = cellfun(@(x) isequal(x, 1), storedResults(:, 1));
            selectedRows = storedResults(idx, :);
        end
        
        function [process, fullD, extended] = extractProcessInfo(app, description)
            
            commaPositions = find(description == ',');
            
            if size(commaPositions, 2) == 2
                process = extractBetween(description, 1, commaPositions(1) - 1);
                fullD = extractBetween(description, 1, commaPositions(2) - 1);
                extended = (char(extractBetween(description, commaPositions(1) + 2, commaPositions(2) - 1)) == 'E');
            else
                process = extractBetween(description, 1, commaPositions - 1);
                fullD = process;
                extended = false;
            end
            
            
        end
        
        function deleteResults(app, folder)
            
            filePattern = fullfile(folder, '*.xlsx');
            theFiles = dir(filePattern);
            
            for k = 1 : length(theFiles)
                baseFileName = theFiles(k).name;
                fullFileName = fullfile(folder, baseFileName);

                delete(fullFileName);
            end
        end
        
        function figure = centerFigure(app, figure)
            % width and height of the figure
            width = figure.Position(3);
            height = figure.Position(4);
            
            % screen size
            sz = get( 0, 'ScreenSize');
            
            % center position
            x = mean( sz( [1, 3]));
            y = mean( sz( [2, 4]));
            
            figure.Position = [x - width/2, y - height/2, width, height];
        end
        
        function app = clearOldFigures(app)
            handles = findall(groot, 'Type', 'figure');
            
            identificationPanel = handles(end);
            if identificationPanel.Name == app.IdentificationPanelUIFigure.Name
                handles(end) = [];
                close(handles);
            end
        end
        
    end
    
    %% utility functions for extacting information from the ui
    methods (Access = private)
        
        % extract the list of selected equations 
        % from the equations checkboxes group
        function selectedEquationsList = extractSelectedModelEquations(app)
            selectedEquationsList = EquationsList();
            
            numberOfModelEquations = length(app.modelEquationsCheckBoxesGroup);
            for index = 1 : numberOfModelEquations
                
                currentEquationCheckBox = app.modelEquationsCheckBoxesGroup(index);
                
                equation = app.descriptionOfSelectedProcess.generalModelDescription.elements(numberOfModelEquations - index + 1);
                if currentEquationCheckBox.Value
                    selectedEquationsList = selectedEquationsList.addEquation(equation);
                else
                    if equation.isCompulsory
                        currentEquationCheckBox.Value = 1;
                        selectedEquationsList = selectedEquationsList.addEquation(equation);
                    end
                end
            end
        end
        
        % extract the specified values for the parameters of the selected optimization algorithm
        function app = extractParameterValues(app, panel)
            % find all the numeric fields in the parent panel
            parameterFields = findall(panel.Children, 'Type', 'uinumericeditfield');
            numberOfParameterFields = length(parameterFields);
            
            for index = 1: numberOfParameterFields
                
                currentField = parameterFields(index); 
                app.descriptionOfAlgorithm.parametersList(index).value = currentField.Value;
                
            end
        end
        
        function app = extractProblemParameterValues(app)
            % find all the numeric fields in the parent panel
            parameterFields = findall(app.ProblemParametersPanel.Children, 'Type', 'uinumericeditfield');
            numberOfParameterFields = length(parameterFields);
            
            app.descriptionOfAlgorithm.initialPopulation = [];
            
            for index = 1: numberOfParameterFields
                
                currentField = parameterFields(index);        
                app.descriptionOfAlgorithm.initialPopulation(end + 1) = currentField.Value;
                 
            end
        end
        
        function app = extractOptimizationAlgorithmParameterValues(app)
            app = app.extractParameterValues(app.ParametersPanel);
            
            if ~app.descriptionOfAlgorithm.hasRandomInitialPopulation
                % these values are used as an initial solution by the algorithm
                app = app.extractProblemParameterValues();
            end 
        end
    end

    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            app.system = System();
            
            % Load the list of fermentation processes into the drop-down
            app.ProcessDropDown.Items = app.system.getListOfFPDescriptions();
            app.ProcessDropDown.ItemsData = app.system.listOfFermetationProcesses;
            
            app.ModelKineticsPanel.Visible = 'Off';
                       
            % Set the selected item of the drop-down to the first element
            %app.descriptionOfSelectedProcess = app.system.listOfFermetationProcesses(1);
            
            %app.ProcessDropDown.Value = app.descriptionOfSelectedProcess;
           
            % Load the ModelKinticsPanel for the selected process
            %app.setPanelsWhenFermetationProcessIsChosen(app.descriptionOfSelectedProcess, []);
            
            % Load the list of optimization algorithmz into the drop-down
            app.AlgorithmDropDown.Items = app.system.getListOfOptimizationAlgorithmDescriptions();
            app.AlgorithmDropDown.ItemsData = app.system.listOfOptimizationAlgorithms;
            
            app.OptimizationAlgorithmPanel.Visible = 'Off';
            
            app.OptimizationAlgorithmParametersPanel.Visible = 'Off';
            
            app.GAParametersPanel.Visible = 'Off';
            
            app.ParametersPanel.Visible = 'Off';
            app.ProblemParametersPanel.Visible = 'Off';
            
            app.RunSimulationButtonsPanel.Visible = 'Off';
            
            app.IdentificationPanelUIFigure = app.centerFigure(app.IdentificationPanelUIFigure);
        end

        % Value changed function: AlgorithmDropDown
        function AlgorithmDropDownValueChanged(app, event)
                        
            app.descriptionOfAlgorithm = app.AlgorithmDropDown.Value;
            
            % no value is selected or the selected algorithm is the dummy one
            if isempty(app.descriptionOfAlgorithm) || app.descriptionOfAlgorithm.isEmpty()
                app.ParametersPanel.Visible = 'Off';
                app.ProblemParametersPanel.Visible = 'Off';
                return;
            end
                                  
            % Load the AlgorithmParametersPanel with the default values of the necessary algorithm parameters
            app.OptimizationAlgorithmParametersPanel.Visible = 'On';
            app.ParametersPanel.Visible = 'On';
            
            app.drawAlgorithmParametersPanel();
            
            if ~app.descriptionOfAlgorithm.hasRandomInitialPopulation
                app.ProblemParametersPanel.Visible = 'On';
                app.drawProblemParametersPanel();
            else
                app.ProblemParametersPanel.Visible = 'Off';
            end
            
            app.RunSimulationButtonsPanel.Visible = 'On';
            
        end

        % Button pushed function: CompareResultsButton
        function CompareResultsButtonPushed(app, event)
            %             set(gcf,'Pointer','watch');
            %             drawnow update;
            
            selectedRows = app.getSelectedResultsForComparison();
            
            description = char(selectedRows(1, 2));
            [process, fullD, extended] = app.extractProcessInfo(description);
                        
            sameProcess = all(startsWith(string(selectedRows(:, 2)), fullD));
            if ~sameProcess
                uiwait(msgbox('Please choose results for one process only!', 'Error message', 'error', 'modal'));
                return;
            end
            
            % the path to the stored data is in the last colums of the rows (5)         
            handle = DataReader.displayExpData(process, extended);
            
            countRows = size(selectedRows, 1);
            for i = 1: countRows
                
                filePath = char(selectedRows(i, 5));
                algName = char(selectedRows(i, 3));
                
                DataReader.displayModelData(process, extended, filePath, handle, algName, i);
            end
            
            %             set(gcf,'Pointer','arrow');
            %             drawnow update;
        end

        % Button pushed function: GluconicAcidProcessControlButton
        function GluconicAcidProcessControlButtonPushed(app, event)
            ProcessControlPanel();
            
        end

        % Close request function: IdentificationPanelUIFigure
        function IdentificationPanelUIFigureCloseRequest(app, event)
            delete(app);
            
            % clear all files in the results folders
            configuration = Configurations();
            
            folder = [pwd '\Models\' configuration.ECOLI_RESULTS_PATH];
            app.deleteResults(folder);
            
            folder = [pwd '\Models\' configuration.GAB_RESULTS_PATH];
            app.deleteResults(folder);
        end

        % Selection changed function: KineticsPanel
        function KineticsPanelSelectionChanged(app, event)
            % selectedButton = app.KineticsPanel.SelectedObject;
            app.LoadDataButton.Enable = 'Off';
            app.OptimizationAlgorithmPanel.Visible = 'off';
            
            % hide the algorithms
            app.AlgorithmDropDown.Value = app.AlgorithmDropDown.ItemsData(1);
            
            app.OptimizationAlgorithmParametersPanel.Visible = 'off';
            app.ProblemParametersPanel.Visible = 'off';
        end

        % Value changed function: LoadDataButton
        function LoadDataButtonPushed(app, event)
            
            if isempty(app.descriptionOfSelectedProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
            
            path = char(app.selectedProcess.model.pathToExperimentalData);
            fileStart = 1 + find(path == '\', 1, 'last');
            file = path(fileStart: end);
            
            app.LoadExperimentalDataCheckBox.Value = 1;
            app.logInfo('Data', file);
            
            %             % get the folder associated with the selected process
            %             folder = app.descriptionOfSelectedProcess.dataFolder;
            %             
            %             % Set filter for the files, use filter as an argument of uigetfile
            %             filter = strcat(folder, "\*.*");
            %             
            %             % app.descriptionOfSelectedProcess.pathToExperimentalData = 
            %             [file, path] = uigetfile(char(filter));
            %             
            %             % no file has been selected
            %             if file ~= 0
            %                 app.selectedProcess.model.pathToExperimentalData = [path file];
            %                 app.LoadExperimentalDataCheckBox.Value = 1;
            %                 app.logInfo('Data', file);
            %             else
            %                 % uiwait(msgbox('Please choose experimental data!', 'Info', 'Info', 'modal'));
            %                 
            %                 options = struct('WindowStyle','modal', 'Interpreter','tex');
            %                 uiwait(errordlg('Please choose experimental data!', 'Error', options));
            %             end
            
            app.OptimizationAlgorithmPanel.Visible = 'On';
            
            % Set the first item in the drop-down as the selected one
            app.AlgorithmDropDown.Value = app.system.listOfOptimizationAlgorithms(1);
            
            app.LoadDataButton.Enable = 'Off';
        end

        % Value changed function: ProcessDropDown
        function ProcessDropDownValueChanged(app, event)
            app.clearStepInfoPanel();
            
            app.LoadDataButton.Enable = 'Off';
            
            app.descriptionOfSelectedProcess = app.ProcessDropDown.Value; 
                       
            previouslySelectedValue = [];
            
            if ~isempty(event)
                previouslySelectedValue = event.PreviousValue;
            end
            
            app.setPanelsWhenFermetationProcessIsChosen(app.descriptionOfSelectedProcess, previouslySelectedValue);
        end

        % Button pushed function: RunButton
        function RunStoreButtonValueChanged(app, event)
            
            app.clearOldFigures();
            
            % find all the numeric fields in the parent panel
            app = app.extractOptimizationAlgorithmParameterValues();
            
            app.ModelParameterIdentificationCheckBox.Value = 1;
            
            % call the AlgorithmFactory class to generate an object for the selected algorithm
            app.selectedAlgorithm = ...
                OptimizationAlgorithmFactory.createOptimizationAlgorithm(app.descriptionOfAlgorithm, app.selectedProcess);
            
            [app.selectedAlgorithm, result] = app.selectedAlgorithm.execute();
            
            % update the model
            %             app.selectedProcess.model = app.selectedAlgorithm.problem.model;
            
            % extract the best solution, mean error and plot the results
            [app.selectedProcess.model, bestSolution, meanError, filename] = app.selectedProcess.model.process(result);
            
            FileSaver.saveAlgorithmData(app.selectedAlgorithm, filename);
            FileSaver.saveBestSolution(bestSolution, filename);
            
            % add record to the ui table with the simulation results
            app.addResultRecord(bestSolution, meanError, filename);
            
            app.CompareResultsButton.Enable = 'On';
        end

        % Button pushed function: SetModelButton
        function SetModelButtonPushed(app, event)
            
            app.SelectModelandKineticsCheckBox.Value = 1;
                       
            % find the selected checkboxes 
            if isempty(app.modelEquationsCheckBoxesGroup)
                uiwait(msgbox('No model equations are found!', 'Error message', 'error', 'modal'));
                return;
            end
            
            selectedEquationsList = app.extractSelectedModelEquations();
            
            % find the selected kinetic
            selectedKinetics = app.KineticsPanel.SelectedObject.Text;
                        
            newProcess = FermentationProcess(app.descriptionOfSelectedProcess);
            
            if isempty(app.selectedProcess) || ~isequal(app.selectedProcess.description, newProcess.description)
                app.selectedProcess = newProcess;
                app.LoadDataButton.Enable = 'On'; 
            end
            
            try
                app.selectedProcess.model = ProcessModelFactory.createProcessModel(app.descriptionOfSelectedProcess.name, ...
                        selectedEquationsList, selectedKinetics);
            catch exception
                uiwait(msgbox(exception.message, 'Error message', 'error', 'modal'));
                return;
            end
            
            if app.LoadExperimentalDataCheckBox.Value == 1
                    app.OptimizationAlgorithmPanel.Visible = 'on';
                    app.ProblemParametersPanel.Visible = 'off';
            end
            
        end

        % Callback function
        function chooseProcessDropDown_itemChanged(app, event)
            
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.IdentificationPanelUIFigure = uifigure;
            app.IdentificationPanelUIFigure.Name = 'Identification Panel';
            app.IdentificationPanelUIFigure.CloseRequestFcn = createCallbackFcn(app, @IdentificationPanelUIFigureCloseRequest, true);
            app.IdentificationMainPanel = uipanel(app.IdentificationPanelUIFigure);
            app.NavigaationPanel = uipanel(app.IdentificationMainPanel);
            app.StepInfoPanel = uipanel(app.NavigaationPanel);
            app.StepInfoPanel.Title = 'Current Step';
            app.SelectFermentionProcessCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectFermentionProcessCheckBox.Enable = 'off';
            app.SelectFermentionProcessCheckBox.Text = 'Select Fermention Process';
            app.SelectModelandKineticsCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectModelandKineticsCheckBox.Enable = 'off';
            app.SelectModelandKineticsCheckBox.Text = 'Select Model and Kinetics';
            app.ModelParameterIdentificationCheckBox = uicheckbox(app.StepInfoPanel);
            app.ModelParameterIdentificationCheckBox.Enable = 'off';
            app.ModelParameterIdentificationCheckBox.Text = 'Model Parameter Identification';
            app.LoadExperimentalDataCheckBox = uicheckbox(app.StepInfoPanel);
            app.LoadExperimentalDataCheckBox.Enable = 'off';
            app.LoadExperimentalDataCheckBox.Text = 'Load Experimental Data';
            app.GluconicAcidProcessControlButton = uibutton(app.NavigaationPanel, 'push');
            app.GluconicAcidProcessControlButton.ButtonPushedFcn = createCallbackFcn(app, @GluconicAcidProcessControlButtonPushed, true);
            app.GluconicAcidProcessControlButton.Text = 'Gluconic Acid Process Control';
            app.SettingsPanel = uipanel(app.IdentificationMainPanel);
            app.SettingsOfFermentationProcessPanel = uipanel(app.SettingsPanel);
            app.ModelKineticsPanel = uipanel(app.SettingsOfFermentationProcessPanel);
            app.ModelKineticsPanel.Title = 'Choose Model and Kinetics';
            app.KineticsPanel = uibuttongroup(app.ModelKineticsPanel);
            app.KineticsPanel.SelectionChangedFcn = createCallbackFcn(app, @KineticsPanelSelectionChanged, true);
            app.KineticsPanel.Title = 'Kinetic Models';
            app.MassBalanceEquationsPanel = uipanel(app.ModelKineticsPanel);
            app.MassBalanceEquationsPanel.Title = 'Mass Balance Equations';
            app.SetModelButtonPanel = uipanel(app.ModelKineticsPanel);
            app.SetModelButton = uibutton(app.SetModelButtonPanel, 'push');
            app.SetModelButton.ButtonPushedFcn = createCallbackFcn(app, @SetModelButtonPushed, true);
            app.SetModelButton.Text = 'Set Model';
            app.LoadDataButton = uibutton(app.SetModelButtonPanel, 'state');
            app.LoadDataButton.ValueChangedFcn = createCallbackFcn(app, @LoadDataButtonPushed, true);
            app.LoadDataButton.Enable = 'off';
            app.LoadDataButton.Text = 'Load Data';
            app.ProcessTypePanel = uipanel(app.SettingsOfFermentationProcessPanel);
            app.ProcessTypePanel.Title = 'Choose Fermetation Process';
            app.ProcessDropDown = uidropdown(app.ProcessTypePanel);
            app.ProcessDropDown.Items = {};
            app.ProcessDropDown.ValueChangedFcn = createCallbackFcn(app, @ProcessDropDownValueChanged, true);
            app.ProcessDropDown.Value = {};
            app.InformationPanel = uipanel(app.IdentificationMainPanel);
            app.LogsPanel = uipanel(app.InformationPanel);
            app.LogsPanel.Title = 'Logs';
            app.LogsUITable = uitable(app.LogsPanel);
            app.LogsUITable.ColumnName = {'Step'; 'Record'};
            app.LogsUITable.RowName = {};
            app.LogsUITable.Enable = 'off';
            app.SimulationResultsUITable = uitable(app.LogsPanel);
            app.SimulationResultsUITable.ColumnName = {'Selected'; 'MK'; 'ALG'; 'Results'; ''};
            app.SimulationResultsUITable.RowName = {};
            app.SimulationResultsUITable.ColumnEditable = [true false false false false];
            app.CompareResultsButton = uibutton(app.LogsPanel, 'push');
            app.CompareResultsButton.ButtonPushedFcn = createCallbackFcn(app, @CompareResultsButtonPushed, true);
            app.CompareResultsButton.Enable = 'off';
            app.CompareResultsButton.Text = 'Compare Results';
            app.OptimizationAlgorithmPanel = uipanel(app.IdentificationMainPanel);
            app.OptimizationAlgorithmPanel.Title = 'Choose Algoithm';
            app.AlgorithmDropDown = uidropdown(app.OptimizationAlgorithmPanel);
            app.AlgorithmDropDown.Items = {};
            app.AlgorithmDropDown.ValueChangedFcn = createCallbackFcn(app, @AlgorithmDropDownValueChanged, true);
            app.AlgorithmDropDown.Value = {};
            app.OptimizationAlgorithmParametersPanel = uipanel(app.OptimizationAlgorithmPanel);
            app.OptimizationAlgorithmParametersPanel.Title = 'Set Algorithm Parameters';
            app.GAParametersPanel = uipanel(app.OptimizationAlgorithmParametersPanel);
            app.MUTRLabel = uilabel(app.GAParametersPanel);
            app.MUTRLabel.Text = 'MUTR';
            app.MutrEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.MutrEditField.Limits = [0.001 0.1];
            app.MutrEditField.Value = 0.01;
            app.MutrRangeLabel = uilabel(app.GAParametersPanel);
            app.MutrRangeLabel.Text = '(0.001, 0.1)';
            app.XovrRangeLabel = uilabel(app.GAParametersPanel);
            app.XovrRangeLabel.Text = '(0.1, 1.0)';
            app.XOVRLabel = uilabel(app.GAParametersPanel);
            app.XOVRLabel.Text = 'XOVR';
            app.XovrEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.XovrEditField.Limits = [0.1 1];
            app.XovrEditField.Value = 0.7;
            app.NindRangeLabel = uilabel(app.GAParametersPanel);
            app.NindRangeLabel.Text = '(1, 200)';
            app.NINDLabel = uilabel(app.GAParametersPanel);
            app.NINDLabel.Text = 'NIND';
            app.NindEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.NindEditField.Limits = [1 200];
            app.NindEditField.ValueDisplayFormat = '%.0f';
            app.NindEditField.Value = 100;
            app.MaxGenRangeLabel = uilabel(app.GAParametersPanel);
            app.MaxGenRangeLabel.Text = '(1, 400)';
            app.MAXGENLabel = uilabel(app.GAParametersPanel);
            app.MAXGENLabel.Text = 'MAXGEN';
            app.MaxGenEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.MaxGenEditField.Limits = [1 400];
            app.MaxGenEditField.ValueDisplayFormat = '%.0f';
            app.MaxGenEditField.Value = 100;
            app.GGapRangeLabel = uilabel(app.GAParametersPanel);
            app.GGapRangeLabel.Text = '(0.1, 1)';
            app.GGAPLabel = uilabel(app.GAParametersPanel);
            app.GGAPLabel.Text = 'GGAP';
            app.GGapEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.GGapEditField.Limits = [0.1 1];
            app.GGapEditField.Value = 0.9;
            app.NRunRangeLabel = uilabel(app.GAParametersPanel);
            app.NRunRangeLabel.Visible = 'off';
            app.NRunRangeLabel.Text = '(1, 100)';
            app.NRUNLabel = uilabel(app.GAParametersPanel);
            app.NRUNLabel.Visible = 'off';
            app.NRUNLabel.Text = 'NRUN';
            app.NRunEditField = uieditfield(app.GAParametersPanel, 'numeric');
            app.NRunEditField.Limits = [1 100];
            app.NRunEditField.ValueDisplayFormat = '%.0f';
            app.NRunEditField.Visible = 'off';
            app.NRunEditField.Value = 5;
            app.ParametersPanel = uipanel(app.OptimizationAlgorithmParametersPanel);
            app.ProblemParametersPanel = uipanel(app.OptimizationAlgorithmPanel);
            app.ProblemParametersPanel.Title = 'Set Problem Parameters';
            app.RunSimulationButtonsPanel = uipanel(app.OptimizationAlgorithmPanel);
            app.RunSimulationButtonsPanel.Title = ' ';
            app.RunButton = uibutton(app.RunSimulationButtonsPanel, 'push');
            app.RunButton.ButtonPushedFcn = createCallbackFcn(app, @RunStoreButtonValueChanged, true);
            app.RunButton.Text = 'Run';
        end
    end

    methods (Access = public)

        % Construct app
        function app = IdentificationPanel_FixedSizeOfModelPanel

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.IdentificationPanelUIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.IdentificationPanelUIFigure)
        end
    end
end