classdef IdentificationPanel < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        IdentificationPanelUIFigure     matlab.ui.Figure
        IdentificationMainPanel         matlab.ui.container.Panel
        NavigaationPanel                matlab.ui.container.Panel
        StepInfoPanel                   matlab.ui.container.Panel
        SelectFermentionProcessCheckBox  matlab.ui.control.CheckBox
        SelectModelandKineticsCheckBox  matlab.ui.control.CheckBox
        ModelParameterIdentificationCheckBox  matlab.ui.control.CheckBox
        LoadExperimentalDataCheckBox    matlab.ui.control.CheckBox
        SettingsPanel                   matlab.ui.container.Panel
        SettingsOfFermentationProcessPanel  matlab.ui.container.Panel
        ProcessTypePanel                matlab.ui.container.Panel
        ProcessDropDown                 matlab.ui.control.DropDown
        ModelKineticsPanel              matlab.ui.container.Panel
        KineticsPanel                   matlab.ui.container.ButtonGroup
        MassBalanceEquationsPanel       matlab.ui.container.Panel
        SetModelButtonPanel             matlab.ui.container.Panel
        SetModelButton                  matlab.ui.control.Button
        LoadDataButton                  matlab.ui.control.StateButton
        OptimizationAlgorithmPanel      matlab.ui.container.Panel
        AlgorithmDropDown               matlab.ui.control.DropDown
        AlgorithmParametersPanel        matlab.ui.container.Panel
        RunSimulationButtonsPanel       matlab.ui.container.Panel
        RunStoreButton                  matlab.ui.control.StateButton
        PlotResultsButton               matlab.ui.control.Button
        MUTRLabel                       matlab.ui.control.Label
        MutrEditField                   matlab.ui.control.NumericEditField
        MutrRangeLabel                  matlab.ui.control.Label
        XovrRangeLabel                  matlab.ui.control.Label
        XOVRLabel                       matlab.ui.control.Label
        XovrEditField                   matlab.ui.control.NumericEditField
        NindRangeLabel                  matlab.ui.control.Label
        NINDLabel                       matlab.ui.control.Label
        NindEditField                   matlab.ui.control.NumericEditField
        MaxGenRangeLabel                matlab.ui.control.Label
        MAXGENLabel_2                   matlab.ui.control.Label
        MaxGenEditField                 matlab.ui.control.NumericEditField
        GGapRangeLabel                  matlab.ui.control.Label
        GGAPLabel                       matlab.ui.control.Label
        GGapEditField                   matlab.ui.control.NumericEditField
        NRunRangeLabel                  matlab.ui.control.Label
        NRUNLabel                       matlab.ui.control.Label
        NRunEditField                   matlab.ui.control.NumericEditField
        InformationPanel                matlab.ui.container.Panel
        LogsPanel                       matlab.ui.container.Panel
        LogsUITable                     matlab.ui.control.Table
    end

    properties
        system    System
        
        descriptionOfSelectedProcess    FermentationProcessDescription
        selectedProcess    FermentationProcess
        
        descriptionOfAlgorithm    AlgorithmDescription
        selectedAlgorithm    OptimizationAlgorithm
        
        % height of a checkbox or a radiobox control
        controlHeight = 25;
        
        % distance between the panels
        distanceBetweenPanels = 10;
        
        % distance between controls
        distanceBetweenControls = 5;
        
        % header and footer heights
        headerHeight = 25;
        footerHeight = 10;
        
        % list of checkboxes
        modelEquationsCheckBoxesGroup
    end
    
    methods (Access = private)
        
        % add row into the log table
        function logInfo(app, stepCode, record)
            
            currentData = app.LogsUITable.Data;
            
            newRecord = {stepCode, char(record)};
            currentData = [currentData; newRecord];
                      
            app.LogsUITable.Data = currentData;
        end
        
        % draws the settings panel
        function app = drawSettingsPanel(app, descriptionOfFermentationProcess)
                                   
            numberOfEquations = length(descriptionOfFermentationProcess.generalModelDescription.elements);
            numberOfApplicableKinetics = length(descriptionOfFermentationProcess.listOfKinetics);
            
            maxNumberOfControls = max(numberOfEquations, numberOfApplicableKinetics);
            
            % change the height of the parent panels
            massBalanceEquationsPanelHeight = maxNumberOfControls*(app.controlHeight + app.distanceBetweenControls) + app.footerHeight + app.headerHeight;
          
            modelKineticsPanelHeight = ... % app.distanceBetweenPanels +
                app.SetModelButtonPanel.Position(4) + app.distanceBetweenPanels + ...
                massBalanceEquationsPanelHeight + app.headerHeight;
            
            settingsOfFermentationPanelHeight = modelKineticsPanelHeight + app.distanceBetweenPanels + app.ProcessTypePanel.Position(4);
            
            app.SettingsOfFermentationProcessPanel.Position(1) = 0;
            app.SettingsOfFermentationProcessPanel.Position(2) = app.SettingsPanel.Position(4) - settingsOfFermentationPanelHeight;
            app.SettingsOfFermentationProcessPanel.Position(3) = app.SettingsPanel.Position(3);
            app.SettingsOfFermentationProcessPanel.Position(4) = settingsOfFermentationPanelHeight;
            
            app.ModelKineticsPanel.Position(1) = 0;
            app.ModelKineticsPanel.Position(2) = 0;
            app.ModelKineticsPanel.Position(3) = app.SettingsOfFermentationProcessPanel.Position(3);
            app.ModelKineticsPanel.Position(4) = modelKineticsPanelHeight;
            
            app.ProcessTypePanel.Position(1) = 0;
            app.ProcessTypePanel.Position(2) = app.ModelKineticsPanel.Position(2) + app.distanceBetweenPanels + app.ModelKineticsPanel.Position(4);
            app.ProcessTypePanel.Position(3) = app.SettingsOfFermentationProcessPanel.Position(3);
            app.ProcessTypePanel.Position(4) = 80;
            
            app.SetModelButtonPanel.Position(1) = 0; % app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(2) = 0; % app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(3) = app.ModelKineticsPanel.Position(3); %- 2*app.distanceBetweenPanels;
            app.SetModelButtonPanel.Position(4) = 60;
            
            posY = app.SetModelButtonPanel.Position(2) + app.distanceBetweenPanels + app.SetModelButtonPanel.Position(4);
            
            app.MassBalanceEquationsPanel.Position(1) = app.distanceBetweenPanels;
            app.MassBalanceEquationsPanel.Position(2) = posY;
            app.MassBalanceEquationsPanel.Position(3) = 400;
            app.MassBalanceEquationsPanel.Position(4) = massBalanceEquationsPanelHeight;
            
            app.KineticsPanel.Position(1) = app.MassBalanceEquationsPanel.Position(1) + app.MassBalanceEquationsPanel.Position(3) + app.distanceBetweenPanels;
            app.KineticsPanel.Position(2) = posY;
            app.KineticsPanel.Position(3) = app.ModelKineticsPanel.Position(3) - app.MassBalanceEquationsPanel.Position(3) - 3*app.distanceBetweenPanels;
            app.KineticsPanel.Position(4) = massBalanceEquationsPanelHeight;
  
        end
        
        function clearChildPanels(app, panel)
            
            children = get(panel, 'Children');
            delete(children);
            
        end
        
        % load the list of equations for the selected process
        function loadMassBalanceEquationsPanel(app, descriptionOfFermentationProcess)
            
            if isempty(descriptionOfFermentationProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
                       
            numberOfEquations = length(descriptionOfFermentationProcess.generalModelDescription.elements);
                        
            checkBoxMaxWidth = app.MassBalanceEquationsPanel.Position(3) - 20;         
            
            for index = 1 : numberOfEquations
                
                currentEquation = descriptionOfFermentationProcess.generalModelDescription.elements(index);
                positionY = app.footerHeight + (numberOfEquations - index)*(app.controlHeight + app.distanceBetweenControls);
                
                enabled = 'on';
                text = cellstr(currentEquation.equationText);
                value = 0;
                
                if currentEquation.isCompulsory
                    enabled = 'off';
                    value = 1;
                end
                
                eqCheckBox = uicheckbox(app.MassBalanceEquationsPanel,...
                        'Visible', 'on', ...
                        'Enable', enabled, ...
                        'Text', text, ...
                        'Position', [20 positionY checkBoxMaxWidth app.controlHeight], ...
                        'Value', value);
        
            end
            
             % array of the created checkboxes
            app.modelEquationsCheckBoxesGroup = get(app.MassBalanceEquationsPanel, 'Children');
        end
        
        % load radio buttons controls for the applicable kinetics
        function loadKineticsPanel(app, descriptionOfFermentationProcess)
            
            if isempty(descriptionOfFermentationProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
            
            numberOfApplicableKinetics = length(descriptionOfFermentationProcess.listOfKinetics);
            
            radioButtonMaxWidth = app.KineticsPanel.Position(3) - 40;
            value = 1;
                       
            for index = 1 : numberOfApplicableKinetics
                          
                text = cellstr(descriptionOfFermentationProcess.listOfKinetics(index));
                positionY = app.KineticsPanel.Position(4) - index*(app.controlHeight + app.distanceBetweenControls) - app.headerHeight;
                
                radioButton = uiradiobutton(app.KineticsPanel,...
                        'Visible', 'on', ...
                        'Enable', 'on', ...
                        'Text', text, ...
                        'Position', [20 positionY radioButtonMaxWidth app.controlHeight], ...
                        'Value', value);
                    
                value = 0;
            end
        end
        
        function setPanelsWhenFermetationProcessIsChosen(app, descriptionOfFermentationProcess, previousFermentationProcess)
                     
            % check if the current value is different from the previously selected one
            % only then change the panels
            if ~isempty(previousFermentationProcess) && previousFermentationProcess == descriptionOfFermentationProcess
                return;
            end
            
            if descriptionOfFermentationProcess.isEmpty()
                app.ModelKineticsPanel.Visible = 'Off';
                return;
            end
            
            app.SelectFermentionProcessCheckBox.Value = 1;
            app.logInfo('FP', descriptionOfFermentationProcess.description);
            
            % clear current content of the SettingsOfFermentationProcessPanel
            app.clearChildPanels(app.MassBalanceEquationsPanel);
            
            % clear current content of the KineticsPanel
            app.clearChildPanels(app.KineticsPanel);
            
            % rearrange the main panels
            app = app.drawSettingsPanel(descriptionOfFermentationProcess);
            
            % Show the panel with the list of equations
            app.ModelKineticsPanel.Visible = 'On';
                
            % add the description of the equations to the panel
            app.loadMassBalanceEquationsPanel(descriptionOfFermentationProcess);
            
            % add the applicable kinetics for the selected proccess
            app.loadKineticsPanel(descriptionOfFermentationProcess);
        end
    end

    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            app.system = System();
            
            % Load the list of fermentation processes into the drop-down
            app.ProcessDropDown.Items = app.system.getListOfFPDescriptions();
            app.ProcessDropDown.ItemsData = app.system.listOfFermetationProcesses;
            
            app.ModelKineticsPanel.Visible = 'Off';
                       
            % Set the selected item of the drop-down to the first element
            %app.descriptionOfSelectedProcess = app.system.listOfFermetationProcesses(1);
            
            %app.ProcessDropDown.Value = app.descriptionOfSelectedProcess;
           
            % Load the ModelKinticsPanel for the selected process
            %app.setPanelsWhenFermetationProcessIsChosen(app.descriptionOfSelectedProcess, []);
            
            % Load the list of optimization algorithmz into the drop-down
            app.AlgorithmDropDown.Items = app.system.getListOfOptimizationAlgorithmDescriptions();
            app.AlgorithmDropDown.ItemsData = app.system.listOfOptimizationAlgorithms;
            
            app.OptimizationAlgorithmPanel.Visible = 'Off';
            app.AlgorithmParametersPanel.Visible = 'Off';
        end

        % Value changed function: AlgorithmDropDown
        function AlgorithmDropDownValueChanged(app, event)
                        
            app.descriptionOfAlgorithm = app.AlgorithmDropDown.Value;
            
            % no value is selected or the selected algorithm is the dummy one
            if isempty(app.descriptionOfAlgorithm) || app.descriptionOfAlgorithm.isEmpty()
                app.AlgorithmParametersPanel.Visible = 'Off';
                return;
            end
                       
            % TODO: change to loading the appropriate panel for setting the parameter values
            % Load the AlgorithmParametersPanel with the default values of the necessary algorithm parameters
            if app.descriptionOfAlgorithm.name ~= "Genetic Algorithm"
                app.AlgorithmParametersPanel.Visible = 'Off';
                return;
            end
            
            app.AlgorithmParametersPanel.Visible = 'On';
            
        end

        % Value changed function: LoadDataButton
        function LoadDataButtonPushed(app, event)
            
            if isempty(app.descriptionOfSelectedProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
            
            % get the folder associated with the selected process
            folder = app.descriptionOfSelectedProcess.dataFolder;
            
            % Set filter for the files, use filter as an argument of uigetfile
            filter = strcat(folder, "\*.*");
            
            % app.descriptionOfSelectedProcess.pathToExperimentalData = 
            [file, path] = uigetfile(char(filter));
            
            % no file has been selected
            if file ~= 0
                app.selectedProcess.pathToExperimentalData = path;
                app.LoadExperimentalDataCheckBox.Value = 1;
                app.logInfo('Data', path);
            else
                % uiwait(msgbox('Please choose experimental data!', 'Info', 'Info', 'modal'));
                
                options = struct('WindowStyle','modal', 'Interpreter','tex');
                uiwait(errordlg('Please choose experimental data!', 'Error', options));
            end
            
            app.OptimizationAlgorithmPanel.Visible = 'On';
            
            % Set the first item in the drop-down as the selected one
            app.AlgorithmDropDown.Value = app.system.listOfOptimizationAlgorithms(1);
        end

        % Value changed function: ProcessDropDown
        function ProcessDropDownValueChanged(app, event)
            app.LoadDataButton.Enable = 'Off';
            
            app.descriptionOfSelectedProcess = app.ProcessDropDown.Value; 
                       
            previouslySelectedValue = [];
            
            if ~isempty(event)
                previouslySelectedValue = event.PreviousValue;
            end
            
            app.setPanelsWhenFermetationProcessIsChosen(app.descriptionOfSelectedProcess, previouslySelectedValue);
        end

        % Value changed function: RunStoreButton
        function RunStoreButtonValueChanged(app, event)
                        
            % find all the numeric fields in the parent panel
            parameterFields = findall(app.AlgorithmParametersPanel.Children, 'Type', 'uinumericeditfield');
            numberOfParameterFields = length(parameterFields);
            
            % the fields should be accessed in revered order as the visible one...
            for index = 1: numberOfParameterFields
                currentField = parameterFields(numberOfParameterFields - index);
                app.descriptionOfAlgorithm.parametersList(index).value = currentField.Value
            end
        end

        % Button pushed function: SetModelButton
        function SetModelButtonPushed(app, event)
            
            app.SelectModelandKineticsCheckBox.Value = 1;
            
            % TODO: what kind of information to be logged?
            
            % find the selected checkboxes 
            if isempty(app.modelEquationsCheckBoxesGroup)
                uiwait(msgbox('No model equations are found!', 'Error message', 'error', 'modal'));
                return;
            end
            
            selectedEquationsList = EquationsList();
            
            numberOfModelEquations = length(app.modelEquationsCheckBoxesGroup);
            for index = 1 : numberOfModelEquations
                
                currentEquationCheckBox = app.modelEquationsCheckBoxesGroup(index);
                if currentEquationCheckBox.Value
                    selectedEquationsList = ...
                        selectedEquationsList.addEquation(app.descriptionOfSelectedProcess.generalModelDescription.elements(index));
                end
            end
            
            % find the selected kinetic
            selectedKinetics = app.KineticsPanel.SelectedObject.Text;
                        
            app.selectedProcess = FermentationProcess(app.descriptionOfSelectedProcess);
            
            try
                app.selectedProcess.model = ProcessModelFactory.createProcessModel(app.descriptionOfSelectedProcess.name, ...
                        selectedEquationsList, selectedKinetics);
            catch exception
                uiwait(msgbox(exception.message, 'Error message', 'error', 'modal'));
                return;
            end
            
            app.LoadDataButton.Enable = 'On';
        end

        % Callback function
        function chooseProcessDropDown_itemChanged(app, event)
            
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.IdentificationPanelUIFigure = uifigure;
            app.IdentificationPanelUIFigure.Name = 'Identification Panel';
            app.IdentificationMainPanel = uipanel(app.IdentificationPanelUIFigure);
            app.NavigaationPanel = uipanel(app.IdentificationMainPanel);
            app.StepInfoPanel = uipanel(app.NavigaationPanel);
            app.StepInfoPanel.Title = 'Current Step';
            app.SelectFermentionProcessCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectFermentionProcessCheckBox.Enable = 'off';
            app.SelectFermentionProcessCheckBox.Text = 'Select Fermention Process';
            app.SelectModelandKineticsCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectModelandKineticsCheckBox.Enable = 'off';
            app.SelectModelandKineticsCheckBox.Text = 'Select Model and Kinetics';
            app.ModelParameterIdentificationCheckBox = uicheckbox(app.StepInfoPanel);
            app.ModelParameterIdentificationCheckBox.Enable = 'off';
            app.ModelParameterIdentificationCheckBox.Text = 'Model Parameter Identification';
            app.LoadExperimentalDataCheckBox = uicheckbox(app.StepInfoPanel);
            app.LoadExperimentalDataCheckBox.Enable = 'off';
            app.LoadExperimentalDataCheckBox.Text = 'Load Experimental Data';
            app.SettingsPanel = uipanel(app.IdentificationMainPanel);
            app.SettingsOfFermentationProcessPanel = uipanel(app.SettingsPanel);
            app.ProcessTypePanel = uipanel(app.SettingsOfFermentationProcessPanel);
            app.ProcessTypePanel.Title = 'Choose Fermetation Process';
            app.ProcessDropDown = uidropdown(app.ProcessTypePanel);
            app.ProcessDropDown.Items = {};
            app.ProcessDropDown.ValueChangedFcn = createCallbackFcn(app, @ProcessDropDownValueChanged, true);
            app.ProcessDropDown.Value = {};
            app.ModelKineticsPanel = uipanel(app.SettingsOfFermentationProcessPanel);
            app.ModelKineticsPanel.Title = 'Choose Model and Kinetics';
            app.KineticsPanel = uibuttongroup(app.ModelKineticsPanel);
            app.KineticsPanel.Title = 'Kinetics Models';
            app.MassBalanceEquationsPanel = uipanel(app.ModelKineticsPanel);
            app.MassBalanceEquationsPanel.Title = 'Mass Balance Equations';
            app.SetModelButtonPanel = uipanel(app.ModelKineticsPanel);
            app.SetModelButton = uibutton(app.SetModelButtonPanel, 'push');
            app.SetModelButton.ButtonPushedFcn = createCallbackFcn(app, @SetModelButtonPushed, true);
            app.SetModelButton.Text = 'Set Model';
            app.LoadDataButton = uibutton(app.SetModelButtonPanel, 'state');
            app.LoadDataButton.ValueChangedFcn = createCallbackFcn(app, @LoadDataButtonPushed, true);
            app.LoadDataButton.Enable = 'off';
            app.LoadDataButton.Text = 'Load Data';
            app.OptimizationAlgorithmPanel = uipanel(app.SettingsPanel);
            app.OptimizationAlgorithmPanel.Title = 'Choose Algoithm';
            app.AlgorithmDropDown = uidropdown(app.OptimizationAlgorithmPanel);
            app.AlgorithmDropDown.Items = {};
            app.AlgorithmDropDown.ValueChangedFcn = createCallbackFcn(app, @AlgorithmDropDownValueChanged, true);
            app.AlgorithmDropDown.Value = {};
            app.AlgorithmParametersPanel = uipanel(app.OptimizationAlgorithmPanel);
            app.AlgorithmParametersPanel.Title = 'Set Algorithm Parameters';
            app.RunSimulationButtonsPanel = uipanel(app.AlgorithmParametersPanel);
            app.RunSimulationButtonsPanel.Title = ' ';
            app.RunStoreButton = uibutton(app.RunSimulationButtonsPanel, 'state');
            app.RunStoreButton.ValueChangedFcn = createCallbackFcn(app, @RunStoreButtonValueChanged, true);
            app.RunStoreButton.Text = 'Run';
            app.PlotResultsButton = uibutton(app.RunSimulationButtonsPanel, 'push');
            app.PlotResultsButton.Enable = 'off';
            app.PlotResultsButton.Text = 'Plot Results';
            app.MUTRLabel = uilabel(app.AlgorithmParametersPanel);
            app.MUTRLabel.Text = 'MUTR';
            app.MutrEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.MutrEditField.Limits = [0.001 0.1];
            app.MutrEditField.Value = 0.001;
            app.MutrRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.MutrRangeLabel.Text = '(0.001, 0.1)';
            app.XovrRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.XovrRangeLabel.Text = '(0.1, 1.0)';
            app.XOVRLabel = uilabel(app.AlgorithmParametersPanel);
            app.XOVRLabel.Text = 'XOVR';
            app.XovrEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.XovrEditField.Limits = [0.1 1];
            app.XovrEditField.Value = 0.1;
            app.NindRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.NindRangeLabel.Text = '(1, 100)';
            app.NINDLabel = uilabel(app.AlgorithmParametersPanel);
            app.NINDLabel.Text = 'NIND';
            app.NindEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.NindEditField.Limits = [1 100];
            app.NindEditField.ValueDisplayFormat = '%.0f';
            app.NindEditField.Value = 1;
            app.MaxGenRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.MaxGenRangeLabel.Text = '(1, 100)';
            app.MAXGENLabel_2 = uilabel(app.AlgorithmParametersPanel);
            app.MAXGENLabel_2.Text = 'MAXGEN';
            app.MaxGenEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.MaxGenEditField.Limits = [1 100];
            app.MaxGenEditField.ValueDisplayFormat = '%.0f';
            app.MaxGenEditField.Value = 1;
            app.GGapRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.GGapRangeLabel.Text = '(0.1, 1)';
            app.GGAPLabel = uilabel(app.AlgorithmParametersPanel);
            app.GGAPLabel.Text = 'GGAP';
            app.GGapEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.GGapEditField.Limits = [0.1 1];
            app.GGapEditField.Value = 0.1;
            app.NRunRangeLabel = uilabel(app.AlgorithmParametersPanel);
            app.NRunRangeLabel.Text = '(1, 100)';
            app.NRUNLabel = uilabel(app.AlgorithmParametersPanel);
            app.NRUNLabel.Text = 'NRUN';
            app.NRunEditField = uieditfield(app.AlgorithmParametersPanel, 'numeric');
            app.NRunEditField.Limits = [1 100];
            app.NRunEditField.ValueDisplayFormat = '%.0f';
            app.NRunEditField.Value = 1;
            app.InformationPanel = uipanel(app.IdentificationMainPanel);
            app.LogsPanel = uipanel(app.InformationPanel);
            app.LogsPanel.Title = 'Logs';
            app.LogsUITable = uitable(app.LogsPanel);
            app.LogsUITable.ColumnName = {'Step'; 'Record'};
            app.LogsUITable.RowName = {};
            app.LogsUITable.Enable = 'off';
        end
    end

    methods (Access = public)

        % Construct app
        function app = IdentificationPanel

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.IdentificationPanelUIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.IdentificationPanelUIFigure)
        end
    end
end