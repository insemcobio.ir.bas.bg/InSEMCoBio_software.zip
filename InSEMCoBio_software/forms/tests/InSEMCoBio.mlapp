classdef InSEMCoBio < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        InSemCoBioUIFigure              matlab.ui.Figure
        MainPanel                       matlab.ui.container.Panel
        StepInfoPanel                   matlab.ui.container.Panel
        SelectFermentionProcessCheckBox  matlab.ui.control.CheckBox
        SelectModelandKineticsCheckBox  matlab.ui.control.CheckBox
        ModelParameterIdentificationCheckBox  matlab.ui.control.CheckBox
        SettingsOfFermetationProcessPanel  matlab.ui.container.Panel
        ExperimentalDataPanel           matlab.ui.container.Panel
        PathField                       matlab.ui.control.EditField
        LoadDataButton                  matlab.ui.control.Button
        ProcessTypePanel                matlab.ui.container.Panel
        ProcessDropDown                 matlab.ui.control.DropDown
        ModelKineticsPanel              matlab.ui.container.Panel
        MassBalanceEquationsPanel       matlab.ui.container.Panel
        dxdtCheckBox                    matlab.ui.control.CheckBox
        dSdtCheckBox                    matlab.ui.control.CheckBox
        dAdtCheckBox                    matlab.ui.control.CheckBox
        dO2dtCheckBox                   matlab.ui.control.CheckBox
        dVdtCheckBox                    matlab.ui.control.CheckBox
        KineticsPanel                   matlab.ui.container.ButtonGroup
        MonodButton                     matlab.ui.control.RadioButton
        ContoaButton                    matlab.ui.control.RadioButton
        AndrewsButton                   matlab.ui.control.RadioButton
        SetModelButton                  matlab.ui.control.Button
        ModelParameterIdentificationPanel  matlab.ui.container.Panel
        AlgorithmsDropDown              matlab.ui.control.DropDown
        ChooseAlgorithmLabel            matlab.ui.control.Label
        RunButton                       matlab.ui.control.Button
        LogsPanel                       matlab.ui.container.Panel
        LogsUITable                     matlab.ui.control.Table
    end

    properties
        system     System
        selectedProcess    FermentationProcess
    end
    
    methods (Access = private)
        
        % add row into the log table
        function logInfo(app, stepCode, record)
            
            currentData = app.LogsUITable.Data;
            
            newRecord = {stepCode, char(record)};
            currentData = [currentData; newRecord];
                      
            app.LogsUITable.Data = currentData;
        end
    end

    methods (Access = private)

        % Code that executes after component creation
        function startupFcn(app)
            app.system = System();
            
            % Load the list of fermentation processes into the drop-down 
            app.ProcessDropDown.Items = app.system.getListOfDescriptions();
            app.ProcessDropDown.ItemsData = app.system.listOfFermetationProcesses;
            
            % Set the selected item of the drop-down to the first element
            app.selectedProcess = app.system.listOfFermetationProcesses(1);
            app.ProcessDropDown.Value = app.selectedProcess;
            
            % hide the panels for step 2 and 3
            app.ModelKineticsPanel.Visible = 'Off';
            app.ModelParameterIdentificationPanel.Visible = 'Off';
        end

        % Button pushed function: LoadDataButton
        function LoadDataButtonPushed(app, event)
            
            if isempty(app.selectedProcess)
                uiwait(msgbox('The process is not selected!', 'Error message', 'error', 'modal'));
                return;
            end
            
            % get the folder associated with the selected process
            folder = app.selectedProcess.dataFolder;
            
            % Set filter for the files, use filter as an argument of uigetfile
            filter = strcat(folder, "\*.*");
            
            % app.selectedProcess.pathToExperimentalData = 
            [file, path] = uigetfile(char(filter));
            
            % no file has been selected
            if file ~= 0
                app.selectedProcess.pathToExperimentalData = path;
                
                % show the selected file in the textbox
                app.PathField.Value = file; % path; % path is too long...
                
                % check the step for selection of the fermentation process
                app.SelectFermentionProcessCheckBox.Value = 1;
                
                % show the panels for the model and the kinetics
                app.ModelKineticsPanel.Visible = 'On';
                
                app.logInfo('FP', app.selectedProcess.description);
                app.logInfo('Data', path);
            else
                % uiwait(msgbox('Please choose experimental data!', 'Info', 'Info', 'modal'));
                
                options = struct('WindowStyle','modal', 'Interpreter','tex');
                uiwait(errordlg('Please choose experimental data!', 'Error', options));
            end
        end

        % Value changed function: ProcessDropDown
        function ProcessDropDownValueChanged(app, event)
            
            value = app.ProcessDropDown.Value;
            app.selectedProcess = value;
            
        end

        % Button pushed function: SetModelButton
        function SetModelButtonPushed(app, event)
            
            app.SelectModelandKineticsCheckBox.Value = 1;
            app.ModelParameterIdentificationPanel.Visible = 'On';
        end

        % Callback function
        function chooseProcessDropDown_itemChanged(app, event)
            value = app.ProcessDropDown.Value;
            
        end
    end

    % App initialization and construction
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.InSemCoBioUIFigure = uifigure;
            app.InSemCoBioUIFigure.Name = 'InSemCoBio';
            app.MainPanel = uipanel(app.InSemCoBioUIFigure);
            app.StepInfoPanel = uipanel(app.MainPanel);
            app.StepInfoPanel.Title = 'Current Step';
            app.SelectFermentionProcessCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectFermentionProcessCheckBox.Enable = 'off';
            app.SelectFermentionProcessCheckBox.Text = 'Select Fermention Process';
            app.SelectModelandKineticsCheckBox = uicheckbox(app.StepInfoPanel);
            app.SelectModelandKineticsCheckBox.Enable = 'off';
            app.SelectModelandKineticsCheckBox.Text = 'Select Model and Kinetics';
            app.ModelParameterIdentificationCheckBox = uicheckbox(app.StepInfoPanel);
            app.ModelParameterIdentificationCheckBox.Enable = 'off';
            app.ModelParameterIdentificationCheckBox.Text = 'Model Parameter Identification';
            app.SettingsOfFermetationProcessPanel = uipanel(app.MainPanel);
            app.ExperimentalDataPanel = uipanel(app.SettingsOfFermetationProcessPanel);
            app.ExperimentalDataPanel.Title = 'Load Experimental Data';
            app.PathField = uieditfield(app.ExperimentalDataPanel, 'text');
            app.PathField.Editable = 'off';
            app.PathField.Enable = 'off';
            app.LoadDataButton = uibutton(app.ExperimentalDataPanel, 'push');
            app.LoadDataButton.ButtonPushedFcn = createCallbackFcn(app, @LoadDataButtonPushed, true);
            app.LoadDataButton.Text = 'Load Data';
            app.ProcessTypePanel = uipanel(app.SettingsOfFermetationProcessPanel);
            app.ProcessTypePanel.Title = 'Choose Fermetation Process';
            app.ProcessDropDown = uidropdown(app.ProcessTypePanel);
            app.ProcessDropDown.Items = {};
            app.ProcessDropDown.ValueChangedFcn = createCallbackFcn(app, @ProcessDropDownValueChanged, true);
            app.ProcessDropDown.Value = {};
            app.ModelKineticsPanel = uipanel(app.MainPanel);
            app.ModelKineticsPanel.Title = 'Choose Model and Kinetics';
            app.MassBalanceEquationsPanel = uipanel(app.ModelKineticsPanel);
            app.MassBalanceEquationsPanel.Title = 'Mass Balance Equations';
            app.dxdtCheckBox = uicheckbox(app.MassBalanceEquationsPanel);
            app.dxdtCheckBox.Enable = 'off';
            app.dxdtCheckBox.Text = 'dX/dt = mu*X - F/V*X';
            app.dxdtCheckBox.Value = true;
            app.dSdtCheckBox = uicheckbox(app.MassBalanceEquationsPanel);
            app.dSdtCheckBox.Enable = 'off';
            app.dSdtCheckBox.Text = 'dS/dt = -1/Yxs*mu*X + (So - S)*F/V';
            app.dSdtCheckBox.Value = true;
            app.dAdtCheckBox = uicheckbox(app.MassBalanceEquationsPanel);
            app.dAdtCheckBox.Text = 'dA/dt = 1/Yax*mu*A - F/V*A';
            app.dO2dtCheckBox = uicheckbox(app.MassBalanceEquationsPanel);
            app.dO2dtCheckBox.Text = 'dO2/dt = 1/Yox ....';
            app.dVdtCheckBox = uicheckbox(app.MassBalanceEquationsPanel);
            app.dVdtCheckBox.Enable = 'off';
            app.dVdtCheckBox.Text = 'dV/dt = F';
            app.dVdtCheckBox.Value = true;
            app.KineticsPanel = uibuttongroup(app.ModelKineticsPanel);
            app.KineticsPanel.Title = 'Kinetics Models';
            app.MonodButton = uiradiobutton(app.KineticsPanel);
            app.MonodButton.Text = 'Monod ';
            app.MonodButton.Value = true;
            app.ContoaButton = uiradiobutton(app.KineticsPanel);
            app.ContoaButton.Text = 'Contoa';
            app.AndrewsButton = uiradiobutton(app.KineticsPanel);
            app.AndrewsButton.Text = 'Andrews';
            app.SetModelButton = uibutton(app.ModelKineticsPanel, 'push');
            app.SetModelButton.ButtonPushedFcn = createCallbackFcn(app, @SetModelButtonPushed, true);
            app.SetModelButton.Text = 'Set Model';
            app.ModelParameterIdentificationPanel = uipanel(app.MainPanel);
            app.ModelParameterIdentificationPanel.Title = 'Model Parameter Identification';
            app.AlgorithmsDropDown = uidropdown(app.ModelParameterIdentificationPanel);
            app.AlgorithmsDropDown.Items = {'Genetic Algorithm', 'Evolutionary Algorithm', 'Artificial Bee Colony'};
            app.AlgorithmsDropDown.Value = 'Genetic Algorithm';
            app.ChooseAlgorithmLabel = uilabel(app.ModelParameterIdentificationPanel);
            app.ChooseAlgorithmLabel.Text = 'Choose Algorithm:';
            app.RunButton = uibutton(app.ModelParameterIdentificationPanel, 'push');
            app.RunButton.Text = 'Run';
            app.LogsPanel = uipanel(app.MainPanel);
            app.LogsPanel.Title = 'Logs';
            app.LogsUITable = uitable(app.MainPanel);
            app.LogsUITable.ColumnName = {'Step'; 'Record'};
            app.LogsUITable.RowName = {};
            app.LogsUITable.Enable = 'off';
        end
    end

    methods (Access = public)

        % Construct app
        function app = InSEMCoBio

            % Create and configure components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.InSemCoBioUIFigure)

            % Execute the startup function
            runStartupFcn(app, @startupFcn)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.InSemCoBioUIFigure)
        end
    end
end